# Keil uVision project T801M.uvprojx, settings and files
target app_withoutboot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103_ATF407_256 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.10.0.4
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_withoutboot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ATF407VGT7,USE_STDPERIPH_DRIVER,LIBRARY_VERSION,USE_FULL_ASSERT,AT_START_F407_V1_0
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM4\CoreSupport;.\Libraries\CMSIS\CM4\DeviceSupport;.\Libraries\CMSIS\CM4\DeviceSupport\startup\mdk;.\Project\AT32_Board;.\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group CMSIS
    ./Libraries/CMSIS/CM4/DeviceSupport/: system_stm32f10x.c
    ./Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_stm32f10x_atf407.s
  group main
    ./Project/: main.c stm32f10x_it.c
  group BSP
    ./Project/AT32_Board/: at32_board.c
  group AT32P
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
target app_withboot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103_ATF407_256 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.10.0.4
  cpu: as above
  output: app_withboot +hex
  AfterMake: fromelf.exe --bin -o ./out/with_boot/app_withboot.bin ./out/with_boot/app_withboot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ATF407VGT7,USE_STDPERIPH_DRIVER,LIBRARY_VERSION,USE_FULL_ASSERT,AT_START_F407_V1_0, WITHBOOT
  c include: .\Libraries\CMSIS\CM4\CoreSupport;.\Libraries\CMSIS\CM4\DeviceSupport;.\Libraries\CMSIS;.\Project;.\Printer;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Project\AT32_Board
  asm define: WITHBOOT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
